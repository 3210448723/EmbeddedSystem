# Keil uVision project STM32_DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_DEMO +hex
  c flags: Optim=1
  c include: ..\Source\System\sys;..\Source\System\delay;..\Source\Drivers\exti;..\Source\Drivers\key;..\Source\Drivers\led;..\Source\Drivers\usart
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Source/Application/: STM32F10x.s
  group Application
    ../Source/Application/: main.c
  group Drivers
    ../Source/Drivers/exti/: exti.c
    ../Source/Drivers/key/: key.c
    ../Source/Drivers/led/: led.c
    ../Source/Drivers/usart/: usart.c
  group System
    ../Source/System/delay/: delay.c
    ../Source/System/sys/: sys.c
