# Keil uVision project RealTimeClock.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RealTimeClock +hex
  c flags: Optim=1
  c include: ..\HAEDWARE\key;..\HAEDWARE\led;..\HAEDWARE\rtc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group USER
    ./: main.c
  group HARDWARE
    ../HAEDWARE/key/: key.c
    ../HAEDWARE/led/: led.c
    ../HAEDWARE/rtc/: rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
