# Keil uVision project Temperature_Light.uvproj, settings and files
target Temperature_Light (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103V8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Temperature_Light +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAEDWARE\adc;..\HAEDWARE\key;..\HAEDWARE\led
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c STM32F10x.s
  group HARDWARE
    ../HAEDWARE/adc/: adc.c
    ../HAEDWARE/key/: key.c
    ../HAEDWARE/led/: led.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
