# Keil uVision project GPIO_LED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_LED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\sys
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s GPIO_LED.c
